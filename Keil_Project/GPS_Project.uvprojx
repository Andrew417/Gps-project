# Keil uVision project GPS_Project.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPS_Project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\TM4C123_GH6PM_Drivers\Inc;.\TM4C123_GH6PM_Drivers\GPS_Driver;.\TM4C123_GH6PM_Drivers\LCD_Driver
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/Src
    ./: main.c
  group TM4C123_GH6PM_Drivers
    ./TM4C123_GH6PM_Drivers/: TM4C123_GH6PM_GPIO.c TM4C123_GH6PM_UART.c
  group TM4C123_GH6PM_Drivers/Inc
    ./TM4C123_GH6PM_Drivers/Inc/: TM4C123GH6PM.h TM4C123_GH6PM_UART.h TM4C123_GH6PM_GPIO.h Utils.h
  group TM4C123_GH6PM_Drivers/LCD_Driver
    ./TM4C123_GH6PM_Drivers/LCD_Driver/: LCD.c LCD.h
  group TM4C123_GH6PM_Drivers/GPS_Driver
    ./TM4C123_GH6PM_Drivers/GPS_Driver/: GPS.c GPS.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.1
