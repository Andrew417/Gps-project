# Keil uVision project GPS_Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: GPS_Project
  c flags: Optim=1 uC99=1
  c include: .\TM4C123_GH6PM_Drivers\GPS_Driver;.\TM4C123_GH6PM_Drivers\Inc;.\TM4C123_GH6PM_Drivers\LCD_Driver;.\TM4C123_GH6PM_Drivers\Systick_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/Src
    ./: startup_TM4C123.s main.c
  group TM4C123_GH6PM_Drivers
    ./TM4C123_GH6PM_Drivers/: TM4C123_GH6PM_GPIO.c TM4C123_GH6PM_UART.c
  group TM4C123_GH6PM_Drivers/Inc
    ./TM4C123_GH6PM_Drivers/Inc/: TM4C123_GH6PM_GPIO.h TM4C123_GH6PM_UART.h TM4C123GH6PM.h Utils.h
  group TM4C123_GH6PM_Drivers/LCD_Driver
    ./TM4C123_GH6PM_Drivers/LCD_Driver/: LCD.h LCD.c
  group TM4C123_GH6PM_Drivers/GPS_Driver
    ./TM4C123_GH6PM_Drivers/GPS_Driver/: GPS.c GPS.h
  group TM4C123_GH6PM_Drivers/Systick_Driver
    ./TM4C123_GH6PM_Drivers/Systick_Driver/: Systick.c Systick.h
  group TM4C123_GH6PM_Drivers/Switch_Driver
    ./TM4C123_GH6PM_Drivers/Switch_Driver/: Switch.c Switch.h
